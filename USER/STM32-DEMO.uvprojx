# Keil uVision project STM32-DEMO.uvprojx, settings and files
target KEY-DEMO (5060960::V5.06 update 7 (build 960)::.\aaa)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.1
  cpu: IRAM(0x20000000,0x00005000) IROM(0x08000000,0x00010000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: STM32-DEMO +hex
  c flags: Optim=2 v6Lang=1 v6LangP=5
  c define: USE_STDPERIPH_DRIVER, STM32F10X_HD
  c include: ..\CMSIS;..\FWlib\inc;..\USER
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group startup
    ../CMSIS/startup/: startup_stm32f10x_hd.s
    ./: rtos.s
  group USER
    ./: main.c task.c task.h type.h semaphore.h semaphore.c
software components: CMSIS:CORE 5.6.0
